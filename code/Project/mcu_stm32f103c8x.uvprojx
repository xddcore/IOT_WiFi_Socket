# Keil uVision project mcu_stm32f103c8x.uvprojx, settings and files
target mcu_stm32f103c8x (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mcu_stm32f103c8x +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: ..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\User;..\Hal;..\Gizwits;..\Hal\Hal_relay;..\Hal\Hal_led;..\Hal\ACS712;..\Hal\delay;..\Hal\sys;..\Hal\AT24C02\24CXX;..\Hal\AT24C02\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Lib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_it.c
  group Hal
    ../Hal/Hal_key/: hal_key.c
    ../Hal/Hal_Usart/: hal_uart.c
    ../Hal/Hal_Watchdog/: hal_watchdog.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group realy
    ../Hal/Hal_relay/: Hal_relay.c Hal_relay.h
  group LED
    ../Hal/Hal_led/: Hal_led.c Hal_led.h
  group acs712
    ../Hal/ACS712/: acs712.c adc.c adc.h acs712.h
  group delay
    ../Hal/delay/: delay.c
  group sys
    ../Hal/sys/: sys.c
  group at24c02
    ../Hal/AT24C02/24CXX/: 24cxx.c 24cxx.h
    ../Hal/AT24C02/IIC/: myiic.c myiic.h
